# Keil uVision project uTaskerV1.4.uvprojx, settings and files
target uTaskerV1.4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uTaskerV1_4 +hex
  AfterMake: Make-Binary.bat
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: _COMPILE_KEIL, _STM32
  c include: ..\
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\settings\STM32F1_256_64.sct
  link misc: --entry main
--keep=reset_vect
  group uTasker
    ../../../uTasker/: can_drv.c Driver.c eth_drv.c GlobalTimer.c low_power.c SSC_drv.c Tty_drv.c uFile.c uMalloc.c uNetwork.c USB_drv.c uTasker.c Watchdog.c time_keeper.c i2c_drv.c
  group TCP/IP
    ../../../stack/: arp.c dhcp.c dns.c Ethernet.c ftp.c http.c icmp.c ip.c ip_utils.c NetBIOS.c pop3.c ppp.c smtp.c snmp.c tcp.c telnet.c tftp.c udp.c webutils.c zero_config.c ftp_client.c igmp.c mqtt.c
  group Source Files
    ../: application.c debug.c KeyScan.c modbus_app.c NetworkIndicator.c usb_application.c webInterface.c snmp_mib_handlers.c
  group Hardware
    ../../../Hardware/STM32/: STM32.c STM32_keil_asm.s
  group utFAT
    ../../../uTasker/utFAT/: mass_storage.c mass_storage.h NAND_driver.h
  group MODBUS
    ../../../uTasker/MODBUS/: MODBUS.c modbus.h
  group uGLCDLIB
    ../../../uTasker/uGLCDLIB/: GLCD.c glcd.h glcd_cglcd.h glcd_fonts.h glcd_nokia.h glcd_oled.h glcd_samsung.h glcd_tft.h glcd_toshiba.h LCD.c
target uTaskerV1.4_BM (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: uTaskerV1_4_BM +hex
  AfterMake: Make-Binary-BM.bat
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: _COMPILE_KEIL, _STM32
  c include: ..\
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT5: ROM 0x8018000 size 0xe8000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\settings\STM32F4_1M_196_BM.sct
  link misc: --entry main
--keep=reset_vect
