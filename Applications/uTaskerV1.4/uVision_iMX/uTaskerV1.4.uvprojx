# Keil uVision project uTaskerV1.4.uvprojx, settings and files
target uTaskerV1.4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052:M7 NXP
  pack: NXP.iMXRT_DFP.1.0.3
  cpu: IRAM(0x20000000,0x00060000) IRAM2(0x00000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: uTaskerV1_4 +hex
  AfterMake: Make-Binary.bat MIMXRT1015
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: _COMPILE_KEIL, _iMX
  c include: ..\
  asm define: CORTEX_M7
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: settings/iMX_RT_10xx_FlexSPI_NOR.sct
  link misc: --entry main
--keep=__image_vector_table
  group uTasker
    ../../../uTasker/: can_drv.c Driver.c eth_drv.c GlobalTimer.c low_power.c SSC_drv.c Tty_drv.c uFile.c uMalloc.c uNetwork.c USB_drv.c uTasker.c Watchdog.c time_keeper.c i2c_drv.c SPI_drv.c
  group TCP/IP
    ../../../stack/: arp.c dhcp.c dns.c Ethernet.c ftp.c http.c icmp.c ip.c ip_utils.c NetBIOS.c pop3.c ppp.c smtp.c snmp.c tcp.c telnet.c tftp.c udp.c webutils.c zero_config.c ftp_client.c igmp.c
  group Source Files
    ../: application.c debug.c KeyScan.c modbus_app.c NetworkIndicator.c usb_application.c webInterface.c snmp_mib_handlers.c FreeMaster.c nRF24201.c DMX512.c FreeRTOSapplication.c uCANopenApp.c
  group Header Files
    ../: ADC_Timers.h app_user_files.h application.h application_lcd.h can_tests.h config.h Port_Interrupts.h TaskConfig.h types.h user_glcd_fonts.h widgets.h app_hw_iMX.h debug_hal_iMX.h i2c_tests.h
    ../../../stack/: tcpip.h
  group Hardware
    ../../../Hardware/iMX/: iMX.c
  group utFAT
    ../../../uTasker/utFAT/: mass_storage.c mass_storage.h NAND_driver.h
  group MODBUS
    ../../../uTasker/MODBUS/: MODBUS.c modbus.h
  group uGLCDLIB
    ../../../uTasker/uGLCDLIB/: GLCD.c glcd.h glcd_cglcd.h glcd_fonts.h glcd_nokia.h glcd_oled.h glcd_samsung.h glcd_tft.h glcd_toshiba.h LCD.c
  group uCANopen
    ../../../uTasker/uCANopen/: CANopen.c CO_driver.c CO_Emergency.c CO_HBconsumer.c CO_NMT_Heartbeat.c CO_PDO.c CO_SDO.c CO_SDOmaster.c CO_SYNC.c crc16-ccitt.c
target uTaskerV1.4-BM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.1.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: uTaskerV1_4_BM +hex
  AfterMake: Make-Binary-BM.bat MIMXRT1015
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: _COMPILE_KEIL, _iMX
  c include: ..\
  asm define: CORTEX_M0
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: settings/iMX_RT_10XX_FlexSPI_NOR_BOOT.sct
  link misc: --entry main
--keep=__vector_table
