# IAR project uTaskerV1.4.ewp, settings and files
configuration Debug STM32 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L432KC ST STM32L432KC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: COMPILE_IAR; _STM32
  ICCARM.CCIncludePath2: .; ..\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uTaskerV1.4.bin
  ILINK.IlinkOutputFile: uTaskerV1.4.out
  ILINK.IlinkIcfFile: settings\STM32_RAM_64.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release STM32 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F746ZG ST STM32F746ZG
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: _STM32; COMPILE_IAR
  OBJCOPY.OOCOutputFile: uTaskerV1.4.hex
  ILINK.IlinkIcfFile: settings\STM32_F7_Flash.icf
configuration Release BM STM32 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: _STM32; COMPILE_IAR
  OBJCOPY.OOCOutputFile: uTaskerV1.4_BM.bin
  ILINK.IlinkOutputFile: uTaskerV1.4_BM.out
  ILINK.IlinkIcfFile: settings\uTaskerSTM32_64_20_BM.icf
  group (top)
    ../: application.c debug.c KeyScan.c modbus_app.c NetworkIndicator.c snmp_mib_handlers.c usb_application.c webInterface.c
  group Hardware
    ../../../Hardware/STM32/: STM32.c
  group TCP/IP
    ../../../stack/: arp.c dhcp.c dns.c Ethernet.c ftp.c ftp_client.c http.c icmp.c igmp.c ip.c ip_utils.c NetBIOS.c pop3.c ppp.c smtp.c snmp.c tcp.c tcpip.h telnet.c tftp.c udp.c webutils.c zero_config.c
  group uTasker
    ../../../uTasker/: can_drv.c Driver.c eth_drv.c GlobalTimer.c i2c_drv.c low_power.c SSC_drv.c time_keeper.c Tty_drv.c uFile.c uMalloc.c uNetwork.c USB_drv.c uTasker.c Watchdog.c
  group uTasker/MODBUS
    ../../../uTasker/MODBUS/: MODBUS.c modbus.h
  group uTasker/uGLCDLIB
    ../../../uTasker/uGLCDLIB/: GLCD.c glcd.h glcd_cglcd.h glcd_fonts.h glcd_nokia.h glcd_oled.h glcd_samsung.h glcd_tft.h glcd_toshiba.h LCD.c
  group uTasker/utFAT
    ../../../uTasker/utFAT/: mass_storage.c mass_storage.h NAND_driver.h
