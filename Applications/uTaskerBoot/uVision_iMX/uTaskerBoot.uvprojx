# Keil uVision project uTaskerBoot.uvprojx, settings and files
target uTaskerBootLoader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052:M7 NXP
  pack: NXP.iMXRT_DFP.1.0.3
  cpu: IRAM(0x20000000,0x00060000) IRAM2(0x00000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: uTaskerBoot +hex
  AfterMake: Make-Binary.bat MIMXRT1015
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: _COMPILE_KEIL, _iMX
  c include: ..\
  asm define: CORTEX_M0
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: settings/iMX_RT_10xx_FlexSPI_NOR.sct
  link misc: --entry main
--keep=__image_vector_table
  group Source Files
    ../: uTaskerBootLoader.c
  group Header Files
    ../: config.h types.h
  group Hardware
    ../../../Hardware/iMX/: iMX.c
  group uTasker
    ../../../uTasker/: crypto.c
  group TCP/IP
    ../../../stack/SSL/mbedtls-1.3.10/: aes_mbedTLS.c
