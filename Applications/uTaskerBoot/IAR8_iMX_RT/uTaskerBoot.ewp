# IAR project uTaskerBoot.ewp, settings and files
configuration uTaskerBoot - Flash (ARM)
  General.OGChipSelectEditMenu: MIMXRT1021xxx5A NXP MIMXRT1021xxx5A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: _iMX; _COMPILE_IAR; IDE_TARGET; $TargetBoard$
  ICCARM.CCIncludePath2: .; ..\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uTaskerBoot.bin
  postbuild: Generate.bat $TargetBoard$
  ILINK.IlinkOutputFile: uTaskerBoot.out
  ILINK.IlinkIcfFile: settings\iMX_RT_10XX_FlexSPI_NOR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  ICCARM.CCDefines: _iMX; _COMPILE_IAR
  ILINK.IlinkIcfFile: settings\iMX_RT_1020_SRAM.icf
  group (top)
    ../: config.h types.h uTaskerBootLoader.c
  group Hardware
    ../../../Hardware/iMX/: iMX.c
  group TCP/IP/mbedtls
    ../../../stack/SSL/mbedtls-1.3.10/: aes_mbedTLS.c
  group uTasker
    ../../../uTasker/: crypto.c
