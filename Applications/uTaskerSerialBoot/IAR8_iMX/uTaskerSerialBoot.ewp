# IAR project uTaskerSerialBoot.ewp, settings and files
configuration FallBackLoader (ARM)
  General.OGChipSelectEditMenu: MIMXRT1021xxx5A NXP MIMXRT1021xxx5A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: _iMX; _COMPILE_IAR; iMX_FALLBACK_SERIAL_LOADER; IDE_TARGET; $TargetBoard$; _iMX_SERIAL_LOADER
  ICCARM.CCIncludePath2: .; ..\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uTaskerSerialBoot_BM.bin
  postbuild: Generate.bat 1 $TargetBoard$ $SecretKey$ $Vector$ $Magic$ $Authentication$
  ILINK.IlinkOutputFile: uTaskerSerialBoot.out
  ILINK.IlinkIcfFile: settings\iMX_RT_10xx_FlexSPI_NOR_Boot.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SerialLoader (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MIMXRT1015xxx5A NXP MIMXRT1015xxx5A
  ICCARM.CCDefines: _iMX; _COMPILE_IAR; IDE_TARGET; $TargetBoard$; _iMX_SERIAL_LOADER
  postbuild: Generate.bat 0 $TargetBoard$ $SecretKey$ $Vector$ $Magic$ $Authentication$
  group (top)
    ../: app_hw_kinetis.h config.h disk_loader.c Loader.h serial_loader.c TaskConfig.h types.h usb_application.c usb_device_loader.c usb_host_loader.c webInterface.c
    ../../uTaskerBoot/: uTaskerBootLoader.c
  group Hardware
    ../../../Hardware/iMX/: iMX.c
  group TCP/IP
    ../../../stack/: arp.c Ethernet.c http.c icmp.c ip.c ip_utils.c tcp.c webutils.c
  group TCP/IP/SSL/mbedtls-1.3.10
    ../../../stack/SSL/mbedtls-1.3.10/: aes_mbedTLS.c
  group uTasker
    ../../../uTasker/: crypto.c Driver.c eth_drv.c i2c_drv.c Tty_drv.c uFile.c uMalloc.c USB_drv.c uTasker.c Watchdog.c
  group uTasker/uGLCDLIB
    ../../../uTasker/uGLCDLIB/: GLCD.c
  group uTasker/utFAT
    ../../../uTasker/utFAT/: mass_storage.c mass_storage.h
