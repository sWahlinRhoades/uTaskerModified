# Keil uVision project uTaskerSerialBoot.uvprojx, settings and files
target uTasker_serial_boot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.1.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: uTaskerSerialBoot +hex
  AfterMake: Make-Binary.bat 0 MIMXRT1015
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: _COMPILE_KEIL, _iMX,_iMX_SERIAL_LOADER
  c include: ..\
  asm define: CORTEX_M4
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: settings/iMX_RT_10XX_FlexSPI_NOR_BOOT.sct
  link misc: --entry main
--keep=__vector_table
  group uTasker
    ../../../uTasker/: Driver.c Tty_drv.c uFile.c uMalloc.c uTasker.c Watchdog.c USB_drv.c eth_drv.c crypto.c
  group Source Files
    ../: webInterface.c usb_application.c usb_device_loader.c usb_host_loader.c serial_loader.c disk_loader.c modbus_app.c
    ../../uTaskerBoot/: uTaskerBootLoader.c
  group Header Files
    ../: app_hw_kinetis.h config.h Loader.h TaskConfig.h types.h
  group Hardware
    ../../../Hardware/iMX/: iMX.c
  group utFAT
    ../../../uTasker/utFAT/: mass_storage.c
  group TCP/IP
    ../../../stack/: ip_utils.c arp.c Ethernet.c http.c icmp.c ip.c tcp.c webutils.c
    ../../../stack/SSL/mbedtls-1.3.10/: aes_mbedTLS.c
